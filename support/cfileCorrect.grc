options:
  parameters:
    author: ZeeTulsa
    generate_options: no_gui
    id: cfileGainCorrect
    output_language: python
    run_options: run
    title: Gain Correction
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/zee/rf/projects/porglet/support/Parrot_DISCO_2440_0284.cfile
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/zee/rf/projects/porglet/support/Parrot_DISCO_2440_0284.tmp
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.0001'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
